options:
  parameters:
    author: yewentai
    generate_options: qt_gui
    id: rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Bandwidth
  id: variable_qtgui_range
  parameters:
    start: 200e3
    step: '100'
    stop: 56e6
    value: 20e6
  states: {}
- name: Frequency
  id: variable_qtgui_range
  parameters:
    start: 70e6
    step: '1000'
    stop: 6000e6
    value: 870e6
  states: {}
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '40'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ../file/rx.dat
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*samp_rate
    samp_rate: samp_rate
    sym_rate: '1.0'
    type: fir_filter_ccf
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    bw0: Bandwidth
    center_freq0: Frequency
    dev_addr: '"serial="'
    gain0: RF_Gain
    samp_rate: Bandwidth
    sync: sync
    type: fc32
  states: {}

connections:
- [root_raised_cosine_filter_0, '0', blocks_file_sink_0_0, '0']
- [uhd_usrp_source_0, '0', root_raised_cosine_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
