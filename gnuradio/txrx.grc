options:
  parameters:
    author: Junchen Zhu
    generate_options: qt_gui
    id: txrx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: RF_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 870e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Junchen Zhu\Downloads\Auto-Encoder-in-SIMO-System\file\rx.dat
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Junchen Zhu\Downloads\Auto-Encoder-in-SIMO-System\file\tx.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '20'
    samp_rate: samp_rate
    sym_rate: bandwidth
    type: ccc
  states: {}
- name: filter_fft_rrc_filter_0_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '20'
    samp_rate: samp_rate
    sym_rate: bandwidth
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: bandwidth
    center_freq0: center_freq
    dev_addr: '"serial=31DB53A"'
    gain0: RF_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    bw0: bandwidth
    center_freq0: center_freq
    dev_addr: '"serial=31DB53A"'
    gain0: RF_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', filter_fft_rrc_filter_0, '0']
- [blocks_throttle2_0_0, '0', filter_fft_rrc_filter_0_0, '0']
- [filter_fft_rrc_filter_0, '0', uhd_usrp_sink_0, '0']
- [filter_fft_rrc_filter_0_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_throttle2_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
