options:
  parameters:
    author: yewentai
    generate_options: qt_gui
    id: tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Bandwidth
  id: variable_qtgui_range
  parameters:
    start: 200e3
    step: '100'
    stop: 56e6
    value: 20e6
  states: {}
- name: Frequency
  id: variable_qtgui_range
  parameters:
    start: 70e6
    step: '1000'
    stop: 6000e6
    value: 870e6
  states: {}
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '40'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: ../file/tx.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: Bandwidth
    center_freq0: Frequency
    dev_addr: '"serial="'
    gain0: RF_Gain
    samp_rate: Bandwidth
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_file_source_0_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
