options:
  parameters:
    generate_options: qt_gui
    id: txrxfile
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/wentai/Codes/Auto-Encoder-in-SIMO-System/file/rx.dat
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/wentai/Codes/Auto-Encoder-in-SIMO-System/file/tx.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.1'
    seed: '0'
    taps: 1.0+1j
  states: {}
- name: channels_fading_model_0
  id: channels_fading_model
  parameters:
    LOS: 'False'
    N: '8'
    fDTs: 10.0/samp_rate
    seed: '0'
  states: {state: disabled}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '20'
    samp_rate: samp_rate
    sym_rate: symbol_rate
    type: ccc
  states: {state: bypassed}
- name: filter_fft_rrc_filter_0_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '20'
    samp_rate: samp_rate
    sym_rate: symbol_rate
    type: ccc
  states: {state: bypassed}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [blocks_throttle2_0, '0', filter_fft_rrc_filter_0, '0']
- [channels_channel_model_0, '0', filter_fft_rrc_filter_0_0, '0']
- [channels_fading_model_0, '0', filter_fft_rrc_filter_0_0, '0']
- [filter_fft_rrc_filter_0, '0', channels_channel_model_0, '0']
- [filter_fft_rrc_filter_0, '0', channels_fading_model_0, '0']
- [filter_fft_rrc_filter_0_0, '0', blocks_file_sink_0, '0']
- [filter_fft_rrc_filter_0_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
