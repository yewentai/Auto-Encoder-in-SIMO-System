options:
  parameters:
    author: yewentai
    generate_options: qt_gui
    id: channel_simo
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: ../file/rx2.dat
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: ../file/tx.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_fading_model_0
  id: channels_fading_model
  parameters:
    LOS: 'False'
    N: '8'
    fDTs: 0.01/samp_rate
    seed: '0'
  states: {}

connections:
- [blocks_file_source_0_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', channels_fading_model_0, '0']
- [channels_fading_model_0, '0', blocks_file_sink_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
