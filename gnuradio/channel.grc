options:
  parameters:
    author: yewentai
    generate_options: qt_gui
    id: channel
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ../file/rx.dat
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: ../file/tx.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: '0'
    seed: '0'
    taps: '1.0'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}

connections:
- [blocks_file_source_0_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0_0, '0']
- [channels_channel_model_0_0, '0', blocks_file_sink_0_0, '0']
- [channels_channel_model_0_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
