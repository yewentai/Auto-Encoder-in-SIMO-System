options:
  parameters:
    author: Barry Duggan
    category: Custom
    generate_options: qt_gui
    id: qpsk_sim
    output_language: python
    title: qpsk_sim
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: 'Channel: Frequency Offset'
    start: '0'
    step: '0.001'
    stop: '0.1'
    value: '0'
    widget: counter
  states: {}
- name: geometric_constellation_shaping
  id: variable_constellation_rect
  parameters:
    const_points: '[-0.214+0.601j,-0.093-0.077j,1.016+0.445j,-1.328+0.080j,1.212-0.224j,-0.445-1.018j,-0.258+1.256j,0.801-0.820j,0.126-0.664j,-0.805-0.470j,0.402+1.045j,-0.871+0.802j,0.216-1.310j,-0.675+0.162j,0.557-0.197j,0.367+0.399j]'
    imag_sect: '16'
    real_sect: '16'
    rot_sym: '16'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: 'Channel: Timing Offset'
    start: '1'
    step: '0.0001'
    stop: '1.001'
    value: '1'
    widget: counter
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./file/rx.dat
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./file/tx.dat
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: geometric_constellation_shaping
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: geometric_constellation_shaping
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}

connections:
- [blocks_file_source_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_file_sink_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
